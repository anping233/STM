# Keil uVision project f411_proj.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f411_proj
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe -c  Objects/f411_proj.axf -o  Objects/f411_proj.txt
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output bin/f411_proj.bin Objects/f411_proj.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: STM32F411xE,HSE_STARTUP_TIMEOUT=1000,HSI_VALUE=16000000,HSE_VALUE=25000000,
  c include: ..\src\arch\cmsis\Include;..\src\std_lib\inc;..\src\libs;..\src\main;..\src\std_lib;..\src\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group stb_lib
    ../src/std_lib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group arch
    ../src/arch/cmsis/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../src/arch/cmsis/Source/Templates/: system_stm32f4xx.c
  group main
    ../src/main/: main.c
  group libs
    ../src/libs/: libs.c
  group driver
    ../src/driver/usart/: usart.c
    ../src/driver/: driver.c
    ../src/driver/delay/: delay.c
    ../src/driver/rcc/: rcc.c
    ../src/driver/gpio/: gpio_config.c
    ../src/driver/led/: led.c
